# IAR project test_project.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllfn.h
  General.OGChipSelectMenu: MSP430FR2675 MSP430FR2675
  General.GStackSize2: 256
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: TARGET_IS_MSP430FR2676; TARGET_IS_MSP430FR2XX_4XX
  ICC430.newCCIncludePaths: ../; ../captivate; ../captivate/ADVANCED; ../captivate/BASE; ../captivate/COMM; ../captivate_app; ../captivate_config; ../driverlib/MSP430FR2xx_4xx; ../driverlib
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$/config/lnk430fr2675.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.newCCIncludePaths: ../; ../captivate; ../captivate/ADVANCED; ../captivate/BASE; ../captivate/COMM; ../captivate_app; ../captivate_config; ../driverlib/MSP430FR2xx_4xx
  ICC430.CCOptStrategy: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: main.c
  group captivate
    ../captivate/: captivate.h
  group captivate/ADVANCED
    ../captivate/ADVANCED/: CAPT_Buttons.h CAPT_EMC.h CAPT_Manager.h CAPT_Manager.c CAPT_Trackpad.h CAPT_Calibration.h CAPT_Slider.h
  group captivate/BASE
    ../captivate/BASE/: CAPT_Touch.h rom_map_captivate.h CAPT_ISR.c CAPT_HAL.h CAPT_Type.h rom_captivate.h
  group captivate/BASE/rom_headers
    ../captivate/BASE/rom_headers/: rom_captivate_msp430fr2522_family.h rom_captivate_msp430fr2676_family.h rom_captivate_msp430fr2633_family.h
  group captivate/COMM
    ../captivate/COMM/: FunctionTimer.c CAPT_PingPongBuffer.h UART.c FunctionTimer.h FunctionTimer_Definitions.h CAPT_Protocol.h I2CSlave.c CAPT_CommConfig.h CAPT_Interface.h CAPT_ByteQueue.h I2CSlave.h UART.h I2CSlave_Definitions.h CAPT_Interface.c UART_Definitions.h
  group captivate_app
    ../captivate_app/: CAPT_App.c CAPT_App.h CAPT_BSP.c CAPT_BSP.h
  group captivate_config
    ../captivate_config/: CAPT_UserConfig.c CAPT_UserConfig.h
  group driverlib/MSP430FR2xx_4xx
    ../driverlib/MSP430FR2xx_4xx/: timer_b.h pmm.h sfr.h driverlib.h cs.h eusci_a_spi.h crc.h lcd_e.h mpy32.h eusci_b_spi.h timer_a.h sysctl.h ecomp.h rom_map_driverlib.h rtc.h icc.h tia.h wdt_a.h eusci_a_uart.h adc.h rom_driverlib.h tlv.h framctl.h gpio.h eusci_b_i2c.h sac.h
  group driverlib/MSP430FR2xx_4xx/inc
    ../driverlib/MSP430FR2xx_4xx/inc/: version.h hw_memmap.h
  group driverlib/MSP430FR2xx_4xx/rom_headers
    ../driverlib/MSP430FR2xx_4xx/rom_headers/: rom_driverlib_fr253x_fr263x.h rom_driverlib_fr235x.h rom_driverlib_fr2676.h
  group mathlib
    ../mathlib/: IQmathLib.h QmathLib.h
  group objects
    ../captivate/BASE/libraries/: captivate_fr2676_family.r43
    ../driverlib/MSP430FR2xx_4xx/libraries/: driverlib_fr2676_family.r43
    ../mathlib/libraries/: QmathLib_IAR_MPY32_5xx_6xx_CPUX_large_code_large_data.r43 IQmathLib_IAR_MPY32_5xx_6xx_CPUX_large_code_large_data.r43
